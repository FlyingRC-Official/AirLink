## main/Kconfig.projbuild
```kconfig
menu "AirLink"
config AIRLINK_FORCE_RECOVERY
    bool "Force recovery-only build"
    default n
endmenu
```
